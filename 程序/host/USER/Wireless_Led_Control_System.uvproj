# Keil uVision project Wireless_Led_Control_System.uvproj, settings and files
target Host (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Wireless_Led_Control_System +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\SYSTEM;..\HARDWARE\DISPLAY;..\HARDWARE\USART;..\HARDWARE\TIM
  group USER
    ./: STARTUP.A51 main.c
  group HARDWARE
    ../HARDWARE/DISPLAY/: display.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/TIM/: tim.c
  group SYS
    ../SYSTEM/: delay.c
